.data
globals:
.space 16
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main39
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin min
min31:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $a1, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a1, $v0, $a0
bgtz  $a1, min7
sll   $v0, $a0, 1
addiu $v0, $v0, 1
min33:
jr    $ra
min7:
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     min33
# end min

# begin input
input42:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s3, $a0
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $a0, $v0, 2
jal   alloc
move  $s1, $v0
li    $s2, 1
input22:
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $s3, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $v0, $a0
bgtz  $a0, input11
move  $v0, $s1
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
input11:
sll   $v0, $v0, 2
addu  $s0, $s1, $v0
jal   readln
sw    $v0, 0($s0)
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s2, $v0, 3
j     input22
# end input

# begin distance
distance176:
addiu $sp, $sp, -24
sw    $ra, 20($sp)
sw    $s4, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 2
addiu $a0, $v0, 4
jal   alloc
move  $s1, $v0
li    $s4, 1
distance152:
addiu $a0, $s4, -1
li    $v0, 2
div   $v0, $a0, $v0
lw    $a0, 4($gp)
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
sle   $a1, $v0, $a0
bgtz  $a1, distance140
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s4, $v0, -1
distance117:
addiu $a0, $s4, -1
li    $v0, 2
div   $v0, $a0, $v0
bgez  $v0, distance113
lw    $v0, 0($s1)
sll   $v0, $v0, 1
addiu $v0, $v0, 1
lw    $ra, 20($sp)
lw    $s4, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 24
jr    $ra
distance113:
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $a0, $v0, 2
addu  $a1, $s1, $a0
lw    $a0, 0($a1)
sll   $a2, $a0, 1
addiu $s2, $a2, 1
addiu $a0, $a0, 1
sw    $a0, 0($a1)
sll   $v0, $v0, 1
addiu $s3, $v0, -1
distance83:
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
bgez  $v0, distance79
addiu $a0, $s4, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s4, $v0, -1
j     distance117
distance79:
addiu $a1, $s2, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $a0, $a0, 1
sll   $v0, $v0, 2
addu  $s0, $s1, $v0
lw    $a1, 0($s0)
sll   $a1, $a1, 1
addiu $s2, $a1, 1
lw    $a3, 8($gp)
addiu $a2, $s4, -1
li    $a1, 2
div   $a1, $a2, $a1
sll   $a1, $a1, 2
addu  $a1, $a3, $a1
lw    $a2, 0($a1)
lw    $a1, 12($gp)
addu  $v0, $a1, $v0
lw    $v0, 0($v0)
beq   $a2, $v0, distance46
lw    $v0, 4($s0)
sll   $v0, $v0, 1
addiu $a1, $v0, 1
move  $a0, $s2
jal   min31
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $v0, $v0, 1
sw    $v0, 0($s0)
distance15:
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s3, $v0, -1
j     distance83
distance46:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
sw    $v0, 0($s0)
j     distance15
distance140:
sll   $a1, $v0, 2
addu  $a1, $s1, $a1
subu  $a0, $a0, $v0
sw    $a0, 0($a1)
sll   $v0, $v0, 1
addiu $s4, $v0, 3
j     distance152
# end distance

# begin _main
_main39:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   input42
sw    $v0, 8($gp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 4($gp)
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   input42
sw    $v0, 12($gp)
jal   distance176
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
