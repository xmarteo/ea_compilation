.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main25
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin pow
pow41:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s0, $a0
move  $s1, $a1
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
li    $a0, 1
beq   $v0, $a0, pow53
li    $a0, 2
div   $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
move  $a1, $s1
jal   pow41
move  $a0, $v0
move  $a1, $v0
jal   matmult134
addiu $a1, $s0, -1
li    $a0, 2
div   $a0, $a1, $a0
li    $a1, 2
div   $a1, $a0, $a1
sll   $a1, $a1, 1
beq   $a1, $a0, pow2
move  $a0, $s1
move  $a1, $v0
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
j     matmult134
pow2:
move  $s1, $v0
pow53:
move  $v0, $s1
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
# end pow

# begin matmult
matmult134:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s0, $a0
move  $s1, $a1
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
mul   $v0, $v0, $v0
sll   $a0, $v0, 2
jal   alloc
li    $a2, 1
matmult104:
addiu $a1, $a2, -1
li    $a0, 2
div   $a3, $a1, $a0
lw    $a0, 4($gp)
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $a3, $a0
bgtz  $a0, matmult95
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
matmult95:
li    $a3, 1
matmult94:
addiu $a1, $a3, -1
li    $a0, 2
div   $t0, $a1, $a0
lw    $a0, 4($gp)
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $t0, $a0
bgtz  $a0, matmult85
addiu $a1, $a2, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $a2, $a0, 3
j     matmult104
matmult85:
li    $a0, 1
li    $t0, 1
matmult83:
addiu $a1, $a0, -1
li    $a0, 2
div   $a1, $a1, $a0
lw    $a0, 4($gp)
addiu $t1, $a0, -1
li    $a0, 2
div   $a0, $t1, $a0
slt   $t1, $a1, $a0
bgtz  $t1, matmult74
addiu $t1, $a2, -1
li    $a1, 2
div   $a1, $t1, $a1
mul   $a1, $a0, $a1
addiu $a3, $a3, -1
li    $a0, 2
div   $a0, $a3, $a0
addu  $a1, $a1, $a0
sll   $a1, $a1, 2
addu  $a1, $v0, $a1
addiu $t0, $t0, -1
li    $a3, 2
div   $a3, $t0, $a3
sw    $a3, 0($a1)
sll   $a0, $a0, 1
addiu $a3, $a0, 3
j     matmult94
matmult74:
addiu $t1, $t0, -1
li    $t0, 2
div   $t0, $t1, $t0
addiu $t2, $a2, -1
li    $t1, 2
div   $t1, $t2, $t1
mul   $t1, $a0, $t1
addu  $t1, $t1, $a1
sll   $t1, $t1, 2
addu  $t1, $s0, $t1
lw    $t1, 0($t1)
mul   $t3, $a0, $a1
addiu $t2, $a3, -1
li    $a0, 2
div   $a0, $t2, $a0
addu  $a0, $t3, $a0
sll   $a0, $a0, 2
addu  $a0, $s1, $a0
lw    $a0, 0($a0)
mul   $a0, $t1, $a0
addu  $a0, $t0, $a0
sll   $a0, $a0, 1
addiu $t0, $a0, 1
sll   $a0, $a1, 1
addiu $a0, $a0, 3
j     matmult83
# end matmult

# begin lire
lire80:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
mul   $v0, $v0, $v0
sll   $a0, $v0, 2
jal   alloc
move  $s0, $v0
li    $s2, 1
lire53:
addiu $a0, $s2, -1
li    $v0, 2
div   $a1, $a0, $v0
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
slt   $v0, $a1, $v0
bgtz  $v0, lire44
move  $v0, $s0
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
lire44:
li    $s1, 1
lire43:
addiu $a0, $s1, -1
li    $v0, 2
div   $a1, $a0, $v0
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
slt   $v0, $a1, $v0
bgtz  $v0, lire94
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s2, $v0, 3
j     lire53
lire94:
jal   readln
sll   $v0, $v0, 1
addiu $a0, $v0, 1
lw    $v0, 4($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $a2, $a1, $v0
addiu $a1, $s2, -1
li    $v0, 2
div   $v0, $a1, $v0
mul   $a1, $a2, $v0
addiu $a2, $s1, -1
li    $v0, 2
div   $v0, $a2, $v0
addu  $a1, $a1, $v0
sll   $a1, $a1, 2
addu  $a1, $s0, $a1
addiu $a2, $a0, -1
li    $a0, 2
div   $a0, $a2, $a0
sw    $a0, 0($a1)
sll   $v0, $v0, 1
addiu $s1, $v0, 3
j     lire43
# end lire

# begin affiche
affiche61:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s2, $a0
li    $s1, 1
affiche47:
addiu $a0, $s1, -1
li    $v0, 2
div   $a1, $a0, $v0
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
slt   $v0, $a1, $v0
bgtz  $v0, affiche38
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
affiche38:
li    $s0, 1
affiche37:
addiu $a0, $s0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $v0, 4($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $v0, $a1, $v0
slt   $a1, $a0, $v0
bgtz  $a1, affiche24
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s1, $v0, 3
j     affiche47
affiche24:
addiu $a2, $s1, -1
li    $a1, 2
div   $a1, $a2, $a1
mul   $v0, $v0, $a1
addu  $v0, $v0, $a0
sll   $v0, $v0, 2
addu  $v0, $s2, $v0
lw    $a0, 0($v0)
jal   writeln
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 3
j     affiche37
# end affiche

# begin _main
_main25:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 4($gp)
jal   lire80
sw    $v0, 0($gp)
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
lw    $a1, 0($gp)
jal   pow41
move  $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     affiche61
# end _main
