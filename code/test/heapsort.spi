.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main65
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin swap
swap43:
addiu $a1, $a1, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $a1, 0($v0)
sll   $a1, $a1, 1
addiu $a1, $a1, 1
addiu $a3, $a2, -1
li    $a2, 2
div   $a2, $a3, $a2
sll   $a2, $a2, 2
addu  $a0, $a0, $a2
lw    $a2, 0($a0)
sw    $a2, 0($v0)
addiu $a1, $a1, -1
li    $v0, 2
div   $v0, $a1, $v0
sw    $v0, 0($a0)
jr    $ra
# end swap

# begin output
output35:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a1
li    $s0, 1
output21:
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $s2, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $v0, $a0
bgtz  $a0, output10
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
output10:
sll   $v0, $v0, 2
addu  $v0, $s1, $v0
lw    $a0, 0($v0)
jal   writeln
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 3
j     output21
# end output

# begin input
input42:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s3, $a0
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $a0, $v0, 2
jal   alloc
move  $s1, $v0
li    $s2, 1
input22:
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $s3, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $v0, $a0
bgtz  $a0, input11
move  $v0, $s1
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
input11:
sll   $v0, $v0, 2
addu  $s0, $s1, $v0
jal   readln
sw    $v0, 0($s0)
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s2, $v0, 3
j     input22
# end input

# begin heapsort
heapsort77:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a1
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a0, $v0, -2
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 1
heapsort56:
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgez  $v0, heapsort52
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, -1
heapsort28:
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, heapsort24
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
heapsort24:
sll   $a0, $s1, 1
addiu $a0, $a0, 1
li    $a1, 1
sll   $v0, $v0, 1
addiu $a2, $v0, 1
jal   swap43
sll   $v0, $s1, 1
addiu $a0, $v0, 1
li    $a1, 1
addiu $a2, $s0, -1
li    $v0, 2
div   $v0, $a2, $v0
sll   $v0, $v0, 1
addiu $a2, $v0, -1
jal   downheap106
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, -1
j     heapsort28
heapsort52:
sll   $a0, $s1, 1
addiu $a0, $a0, 1
sll   $v0, $v0, 1
addiu $a1, $v0, 1
addiu $a2, $s2, -1
li    $v0, 2
div   $v0, $a2, $v0
sll   $v0, $v0, 1
addiu $a2, $v0, -1
jal   downheap106
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, -1
j     heapsort56
# end heapsort

# begin downheap
downheap106:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a2
downheap91:
addiu $a0, $a1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 2
addiu $v0, $v0, 3
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a2, $s2, -1
li    $a0, 2
div   $a0, $a2, $a0
sle   $a2, $v0, $a0
bgtz  $a2, downheap75
downheap117:
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
downheap75:
addiu $a2, $v0, 1
sle   $a0, $a2, $a0
bgtz  $a0, downheap66
sll   $v0, $v0, 1
addiu $s0, $v0, 1
downheap40:
addiu $a0, $a1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $a0, $v0, 2
addu  $a0, $s1, $a0
lw    $a0, 0($a0)
addiu $a2, $s0, -1
li    $a1, 2
div   $a2, $a2, $a1
sll   $a1, $a2, 2
addu  $a1, $s1, $a1
lw    $a1, 0($a1)
slt   $a0, $a0, $a1
blez  $a0, downheap117
sll   $a0, $s1, 1
addiu $a0, $a0, 1
sll   $v0, $v0, 1
addiu $a1, $v0, 1
sll   $v0, $a2, 1
addiu $a2, $v0, 1
jal   swap43
sll   $v0, $s1, 1
addiu $s1, $v0, 1
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s2, $v0, 1
j     downheap91
downheap66:
sll   $a0, $v0, 2
addu  $a0, $s1, $a0
lw    $a2, 0($a0)
lw    $a0, 4($a0)
slt   $a0, $a2, $a0
bgtz  $a0, downheap52
sll   $v0, $v0, 1
addiu $s0, $v0, 1
j     downheap40
downheap52:
sll   $v0, $v0, 1
addiu $s0, $v0, 3
j     downheap40
# end downheap

# begin _main
_main65:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
_main51:
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, _main42
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main42:
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   input42
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sw    $v0, 4($gp)
lw    $v0, 4($gp)
sll   $v0, $v0, 1
addiu $a0, $v0, 1
lw    $v0, 0($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
jal   output35
lw    $v0, 4($gp)
sll   $v0, $v0, 1
addiu $a0, $v0, 1
lw    $v0, 0($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
jal   heapsort77
lw    $v0, 4($gp)
sll   $v0, $v0, 1
addiu $a0, $v0, 1
lw    $v0, 0($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
jal   output35
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
j     _main51
# end _main
