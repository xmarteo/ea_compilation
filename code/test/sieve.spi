.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main11
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin sieve
sieve47:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
jal   readln
move  $s1, $v0
sll   $a0, $s1, 2
jal   alloc
move  $s0, $v0
li    $s2, 1
sieve29:
slt   $v0, $s2, $s1
bgtz  $v0, sieve27
li    $a0, 1
jal   writeln
li    $s2, 2
sieve18:
slt   $v0, $s2, $s1
bgtz  $v0, sieve16
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
sieve16:
sll   $v0, $s2, 2
addu  $v0, $s0, $v0
lw    $v0, 0($v0)
bgtz  $v0, sieve60
sieve2:
addiu $s2, $s2, 1
j     sieve18
sieve60:
move  $a0, $s2
jal   writeln
sll   $a0, $s2, 1
sieve10:
slt   $v0, $a0, $s1
blez  $v0, sieve2
sll   $v0, $a0, 2
addu  $v0, $s0, $v0
sw    $zero, 0($v0)
addu  $a0, $a0, $s2
j     sieve10
sieve27:
sll   $v0, $s2, 2
addu  $a0, $s0, $v0
li    $v0, 1
sw    $v0, 0($a0)
addiu $s2, $s2, 1
j     sieve29
# end sieve

# begin _main
_main11:
j     sieve47
# end _main
