.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main14
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin g
g35:
addiu $sp, $sp, -8
sw    $ra, 4($sp)
sw    $s0, 0($sp)
move  $s0, $a0
g24:
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
beq   $v0, $zero, g19
li    $a0, 1
beq   $v0, $a0, g12
addiu $a0, $v0, -2
jal   g35
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $s0, $v0, -1
j     g24
g12:
li    $a0, 1
g61:
lw    $ra, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 8
j     writeln
g19:
li    $a0, 0
j     g61
# end g

# begin f
f30:
f19:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
beq   $v0, $zero, f14
li    $a0, 1
beq   $v0, $a0, f7
addiu $a0, $v0, -2
j     f19
f7:
li    $a0, 1
f45:
j     writeln
f14:
li    $a0, 0
j     f45
# end f

# begin _main
_main14:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 10
jal   f30
li    $a0, 10
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     g35
# end _main
