.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main23
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin tri
tri162:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a2
tri145:
addiu $a0, $a1, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a2, $s2, -1
li    $a0, 2
div   $a0, $a2, $a0
slt   $a0, $v0, $a0
bgtz  $a0, tri134
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
tri134:
sll   $a0, $v0, 2
addu  $a0, $s1, $a0
lw    $a0, 0($a0)
sll   $a0, $a0, 1
addiu $a2, $a0, 1
sll   $v0, $v0, 1
addiu $s0, $v0, 1
addiu $v0, $v0, 3
tri119:
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a3, $s2, -1
li    $a0, 2
div   $a0, $a3, $a0
slt   $a0, $v0, $a0
bgtz  $a0, tri108
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $a0, $v0, 2
addu  $a0, $s1, $a0
lw    $a2, 0($a0)
sll   $a2, $a2, 1
addiu $t1, $a2, 1
addiu $a2, $a1, -1
li    $a1, 2
div   $a1, $a2, $a1
sll   $a2, $a1, 2
addu  $a2, $s1, $a2
lw    $a3, 0($a2)
sw    $a3, 0($a0)
addiu $a3, $t1, -1
li    $a0, 2
div   $a0, $a3, $a0
sw    $a0, 0($a2)
sll   $a0, $s1, 1
addiu $a0, $a0, 1
sll   $a1, $a1, 1
addiu $a1, $a1, 1
sll   $v0, $v0, 1
addiu $a2, $v0, 1
jal   tri162
sll   $v0, $s1, 1
addiu $s1, $v0, 1
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 3
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s2, $v0, 1
j     tri145
tri108:
sll   $a0, $v0, 2
addu  $a0, $s1, $a0
lw    $a3, 0($a0)
addiu $t1, $a2, -1
li    $t0, 2
div   $t0, $t1, $t0
slt   $t0, $a3, $t0
bgtz  $t0, tri100
sll   $v0, $v0, 1
addiu $v0, $v0, 3
j     tri119
tri100:
addiu $t1, $s0, -1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t0, $t0, 1
addiu $s0, $t0, 3
addiu $t1, $s0, -1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t0, $t0, 2
addu  $t0, $s1, $t0
lw    $t1, 0($t0)
sll   $t1, $t1, 1
addiu $t1, $t1, 1
sw    $a3, 0($t0)
addiu $t0, $t1, -1
li    $a3, 2
div   $a3, $t0, $a3
sw    $a3, 0($a0)
sll   $v0, $v0, 1
addiu $v0, $v0, 3
j     tri119
# end tri

# begin lire
lire53:
addiu $sp, $sp, -8
sw    $ra, 4($sp)
sw    $s0, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $a0, $v0, 2
jal   alloc
sw    $v0, 4($gp)
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 1
lire24:
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
bne   $v0, $zero, lire16
lw    $ra, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 8
jr    $ra
lire16:
sll   $v0, $v0, 1
addiu $s0, $v0, -1
jal   readln
sll   $v0, $v0, 1
addiu $a2, $v0, 1
lw    $a1, 4($gp)
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 2
addu  $v0, $a1, $v0
addiu $a1, $a2, -1
li    $a0, 2
div   $a0, $a1, $a0
sw    $a0, 0($v0)
j     lire24
# end lire

# begin affiche
affiche35:
addiu $sp, $sp, -8
sw    $ra, 4($sp)
sw    $s0, 0($sp)
li    $s0, 1
affiche23:
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
lw    $a0, 0($gp)
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $v0, $a0
bgtz  $a0, affiche14
lw    $ra, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 8
jr    $ra
affiche14:
lw    $a0, 4($gp)
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $a0, 0($v0)
jal   writeln
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 3
j     affiche23
# end affiche

# begin _main
_main23:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   lire53
lw    $v0, 4($gp)
sll   $v0, $v0, 1
addiu $a0, $v0, 1
li    $a1, 1
lw    $v0, 0($gp)
addiu $a2, $v0, -1
li    $v0, 2
div   $v0, $a2, $v0
sll   $v0, $v0, 1
addiu $a2, $v0, 1
jal   tri162
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     affiche35
# end _main
