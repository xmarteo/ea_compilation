.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main20
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin coucou
coucou109:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s3, $a0
mul   $v0, $s3, $s3
addu  $a0, $s3, $s3
addu  $a1, $v0, $a0
addu  $v0, $a1, $v0
addu  $v0, $v0, $a0
addu  $v0, $v0, $v0
addu  $v0, $v0, $v0
addu  $s2, $v0, $v0
move  $a0, $s2
jal   writeln
addu  $s1, $s2, $s3
move  $a0, $s1
jal   writeln
addu  $v0, $s2, $s1
addu  $s0, $v0, $s3
move  $a0, $s0
jal   writeln
addu  $v0, $s0, $s2
addu  $v0, $v0, $s1
addu  $a0, $v0, $s3
jal   writeln
subu  $v0, $s3, $s3
subu  $v0, $v0, $s3
subu  $v0, $v0, $s3
subu  $a0, $v0, $s3
jal   writeln
subu  $v0, $s3, $s3
subu  $v0, $s3, $v0
subu  $v0, $s3, $v0
subu  $a0, $s3, $v0
jal   writeln
li    $v0, -10
mul   $a0, $v0, $s3
jal   writeln
li    $v0, 4
div   $a0, $s3, $v0
jal   writeln
li    $v0, 4
div   $v0, $s3, $v0
sll   $v0, $v0, 2
subu  $a0, $s3, $v0
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
j     writeln
# end coucou

# begin _main
_main20:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 0($gp)
_main8:
lw    $a0, 0($gp)
bne   $a0, $zero, _main34
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main34:
jal   coucou109
jal   readln
sw    $v0, 0($gp)
j     _main8
# end _main
