.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main11
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin odd
odd25:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
beq   $v0, $zero, odd8
addiu $a0, $v0, -1
jal   even25
sll   $v0, $v0, 1
addiu $v0, $v0, 1
odd36:
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
odd8:
li    $v0, 1
j     odd36
# end odd

# begin even
even25:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
beq   $v0, $zero, even8
addiu $a0, $v0, -1
jal   odd25
sll   $v0, $v0, 1
addiu $v0, $v0, 1
even36:
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
even8:
li    $v0, 3
j     even36
# end even

# begin check
check27:
addiu $sp, $sp, -8
sw    $ra, 4($sp)
sw    $s0, 0($sp)
li    $s0, 201
check15:
addiu $a0, $s0, -1
li    $v0, 2
div   $a0, $a0, $v0
bgez  $a0, check42
lw    $ra, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 8
jr    $ra
check42:
jal   even25
move  $a0, $v0
jal   writeln
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, -1
j     check15
# end check

# begin _main
_main11:
j     check27
# end _main
