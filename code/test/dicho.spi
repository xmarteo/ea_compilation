.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main65
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin findLoop
findLoop97:
li    $v0, 0
li    $t2, 3
findLoop79:
addiu $t1, $t2, -1
li    $t0, 2
div   $t0, $t1, $t0
bgtz  $t0, findLoop75
jr    $ra
findLoop75:
li    $t2, 1
addiu $t1, $a0, -1
li    $t0, 2
div   $t0, $t1, $t0
addiu $t3, $a1, -1
li    $t1, 2
div   $t1, $t3, $t1
beq   $t0, $t1, findLoop67
addiu $t3, $t0, 1
beq   $t3, $t1, findLoop55
addu  $t1, $t0, $t1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t0, $t0, 1
addiu $t0, $t0, 1
addiu $t1, $t0, -1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t1, $t0, 2
addu  $t1, $a2, $t1
lw    $t3, 0($t1)
addiu $t4, $a3, -1
li    $t1, 2
div   $t1, $t4, $t1
slt   $t4, $t3, $t1
bgtz  $t4, findLoop21
beq   $t3, $t1, findLoop8
sll   $a1, $t0, 1
addiu $a1, $a1, 1
li    $t2, 3
j     findLoop79
findLoop8:
li    $v0, 3
j     findLoop79
findLoop21:
sll   $a0, $t0, 1
addiu $a0, $a0, 1
li    $t2, 3
j     findLoop79
findLoop55:
sll   $v0, $t0, 2
addu  $v0, $a2, $v0
lw    $t1, 0($v0)
addiu $t0, $a3, -1
li    $v0, 2
div   $v0, $t0, $v0
seq   $v0, $t1, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     findLoop79
findLoop67:
li    $v0, 1
j     findLoop79
# end findLoop

# begin find
find101:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
addiu $a0, $a0, -1
li    $v0, 2
div   $a0, $a0, $v0
addiu $a1, $a1, -1
li    $v0, 2
div   $v0, $a1, $v0
beq   $a0, $v0, find78
addiu $a1, $a0, 1
beq   $a1, $v0, find66
addu  $t0, $a0, $v0
li    $a1, 2
div   $a1, $t0, $a1
sll   $a1, $a1, 1
addiu $a1, $a1, 1
addiu $t0, $a1, -1
li    $a1, 2
div   $a1, $t0, $a1
sll   $t0, $a1, 2
addu  $t0, $a2, $t0
lw    $t0, 0($t0)
addiu $t1, $a3, -1
li    $a3, 2
div   $a3, $t1, $a3
slt   $t1, $t0, $a3
bgtz  $t1, find125
beq   $t0, $a3, find13
jal   find101
sll   $v0, $v0, 1
addiu $v0, $v0, 1
find112:
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
find13:
li    $v0, 3
j     find112
find125:
move  $a0, $a1
move  $a1, $v0
jal   find101
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     find112
find66:
sll   $v0, $a0, 2
addu  $v0, $a2, $v0
lw    $v0, 0($v0)
addiu $a1, $a3, -1
li    $a0, 2
div   $a0, $a1, $a0
seq   $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     find112
find78:
li    $v0, 1
j     find112
# end find

# begin _main
_main65:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 16
jal   alloc
sw    $v0, 0($gp)
lw    $a2, 0($gp)
li    $v0, 3
sw    $v0, 0($a2)
li    $v0, 5
sw    $v0, 4($a2)
li    $v0, 7
sw    $v0, 8($a2)
li    $v0, 48
sw    $v0, 12($a2)
li    $a0, 0
li    $a1, 4
li    $a3, 7
jal   find101
bgtz  $v0, _main34
li    $a0, 0
jal   writeln
_main30:
li    $a0, 0
li    $a1, 4
lw    $a2, 0($gp)
li    $a3, 53
jal   find101
bgtz  $v0, _main24
li    $a0, 0
jal   writeln
_main20:
li    $a0, 0
li    $a1, 4
lw    $a2, 0($gp)
li    $a3, 3
jal   findLoop97
bgtz  $v0, _main14
li    $a0, 0
jal   writeln
_main10:
li    $a0, 0
li    $a1, 4
lw    $a2, 0($gp)
li    $a3, 4
jal   findLoop97
bgtz  $v0, _main4
li    $a0, 0
_main87:
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
_main4:
li    $a0, 1
j     _main87
_main14:
li    $a0, 1
jal   writeln
j     _main10
_main24:
li    $a0, 1
jal   writeln
j     _main20
_main34:
li    $a0, 1
jal   writeln
j     _main30
# end _main
