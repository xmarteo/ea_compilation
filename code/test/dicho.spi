.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main85
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin findLoop
findLoop97:
li    $v0, 0
li    $t2, 3
findLoop79:
addiu $t1, $t2, -1
li    $t0, 2
div   $t0, $t1, $t0
bgtz  $t0, findLoop75
jr    $ra
findLoop75:
li    $t2, 1
addiu $t1, $a0, -1
li    $t0, 2
div   $t0, $t1, $t0
addiu $t3, $a1, -1
li    $t1, 2
div   $t1, $t3, $t1
beq   $t0, $t1, findLoop67
addiu $t3, $t0, 1
beq   $t3, $t1, findLoop55
addu  $t1, $t0, $t1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t0, $t0, 1
addiu $t0, $t0, 1
addiu $t1, $t0, -1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t1, $t0, 2
addu  $t1, $a2, $t1
lw    $t3, 0($t1)
addiu $t4, $a3, -1
li    $t1, 2
div   $t1, $t4, $t1
slt   $t4, $t3, $t1
bgtz  $t4, findLoop21
beq   $t3, $t1, findLoop8
sll   $a1, $t0, 1
addiu $a1, $a1, 1
li    $t2, 3
j     findLoop79
findLoop8:
li    $v0, 3
j     findLoop79
findLoop21:
sll   $a0, $t0, 1
addiu $a0, $a0, 1
li    $t2, 3
j     findLoop79
findLoop55:
sll   $v0, $t0, 2
addu  $v0, $a2, $v0
lw    $t1, 0($v0)
addiu $t0, $a3, -1
li    $v0, 2
div   $v0, $t0, $v0
seq   $v0, $t1, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     findLoop79
findLoop67:
li    $v0, 1
j     findLoop79
# end findLoop

# begin find
find123:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $a1, -1
li    $a0, 2
div   $a1, $a1, $a0
beq   $v0, $a1, find100
addiu $a0, $v0, 1
beq   $a0, $a1, find88
addu  $t0, $v0, $a1
li    $a0, 2
div   $a0, $t0, $a0
sll   $a0, $a0, 1
addiu $a0, $a0, 1
addiu $t0, $a0, -1
li    $a0, 2
div   $t0, $t0, $a0
sll   $a0, $t0, 2
addu  $a0, $a2, $a0
lw    $a0, 0($a0)
addiu $t1, $a3, -1
li    $a3, 2
div   $a3, $t1, $a3
slt   $t1, $a0, $a3
bgtz  $t1, find54
beq   $a0, $a3, find24
sll   $v0, $v0, 1
addiu $a0, $v0, 1
sll   $v0, $t0, 1
addiu $a1, $v0, 1
sll   $v0, $a2, 1
addiu $a2, $v0, 1
sll   $v0, $a3, 1
addiu $a3, $v0, 1
jal   find123
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
find134:
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
find24:
li    $v0, 3
j     find134
find54:
sll   $v0, $t0, 1
addiu $a0, $v0, 1
sll   $v0, $a1, 1
addiu $a1, $v0, 1
sll   $v0, $a2, 1
addiu $a2, $v0, 1
sll   $v0, $a3, 1
addiu $a3, $v0, 1
jal   find123
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     find134
find88:
sll   $v0, $v0, 2
addu  $v0, $a2, $v0
lw    $v0, 0($v0)
addiu $a1, $a3, -1
li    $a0, 2
div   $a0, $a1, $a0
seq   $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     find134
find100:
li    $v0, 1
j     find134
# end find

# begin _main
_main85:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 16
jal   alloc
sw    $v0, 0($gp)
lw    $v0, 0($gp)
li    $a0, 3
sw    $a0, 0($v0)
li    $a0, 5
sw    $a0, 4($v0)
li    $a0, 7
sw    $a0, 8($v0)
li    $a0, 48
sw    $a0, 12($v0)
li    $a0, 1
li    $a1, 9
sll   $v0, $v0, 1
addiu $a2, $v0, 1
li    $a3, 15
jal   find123
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, _main49
li    $a0, 0
jal   writeln
_main45:
li    $a0, 1
li    $a1, 9
lw    $v0, 0($gp)
sll   $v0, $v0, 1
addiu $a2, $v0, 1
li    $a3, 107
jal   find123
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, _main34
li    $a0, 0
jal   writeln
_main30:
li    $a0, 1
li    $a1, 9
lw    $v0, 0($gp)
sll   $v0, $v0, 1
addiu $a2, $v0, 1
li    $a3, 7
jal   findLoop97
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, _main19
li    $a0, 0
jal   writeln
_main15:
li    $a0, 1
li    $a1, 9
lw    $v0, 0($gp)
sll   $v0, $v0, 1
addiu $a2, $v0, 1
li    $a3, 9
jal   findLoop97
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, _main4
li    $a0, 0
_main107:
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
_main4:
li    $a0, 1
j     _main107
_main19:
li    $a0, 1
jal   writeln
j     _main15
_main34:
li    $a0, 1
jal   writeln
j     _main30
_main49:
li    $a0, 1
jal   writeln
j     _main45
# end _main
