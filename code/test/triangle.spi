.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main14
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin triangle
triangle51:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s3, $a0
li    $s1, 0
sll   $v0, $s3, 2
addiu $a0, $v0, 4
jal   alloc
move  $s2, $v0
triangle33:
sle   $v0, $s1, $s3
bgtz  $v0, triangle31
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
triangle31:
addiu $s0, $s1, -1
triangle30:
bgtz  $s0, triangle29
li    $v0, 1
sw    $v0, 0($s2)
sll   $v0, $s1, 2
addu  $a0, $s2, $v0
li    $v0, 1
sw    $v0, 0($a0)
li    $s0, 0
triangle10:
sle   $v0, $s0, $s1
bgtz  $v0, triangle8
addiu $s1, $s1, 1
j     triangle33
triangle8:
sll   $v0, $s0, 2
addu  $v0, $s2, $v0
lw    $a0, 0($v0)
jal   writeln
addiu $s0, $s0, 1
j     triangle10
triangle29:
sll   $v0, $s0, 2
addu  $v0, $s2, $v0
lw    $a0, -4($v0)
lw    $a1, 0($v0)
addu  $a0, $a0, $a1
sw    $a0, 0($v0)
addiu $s0, $s0, -1
j     triangle30
# end triangle

# begin _main
_main14:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 0($gp)
lw    $a0, 0($gp)
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     triangle51
# end _main
