.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main74
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin _main
_main74:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 4
jal   writeln
li    $v0, 1
sw    $v0, 4($gp)
lw    $v0, 4($gp)
addu  $v0, $v0, $v0
addiu $a0, $v0, 3
jal   writeln
lw    $v0, 4($gp)
sll   $a0, $v0, 2
jal   writeln
lw    $v0, 4($gp)
sll   $a0, $v0, 2
jal   writeln
lw    $v0, 4($gp)
sll   $a0, $v0, 4
jal   writeln
li    $a0, 0
jal   writeln
lw    $a0, 4($gp)
jal   writeln
lw    $v0, 4($gp)
subu  $v0, $v0, $v0
addiu $v0, $v0, 3
sw    $v0, 0($gp)
lw    $a0, 0($gp)
jal   writeln
li    $a0, 3
lw    $v0, 0($gp)
sle   $a0, $a0, $v0
bgtz  $a0, _main30
_main26:
li    $a0, 1000
lw    $v0, 4($gp)
mul   $v0, $a0, $v0
addiu $a0, $v0, 110
jal   writeln
li    $a0, 24
lw    $v0, 4($gp)
mul   $a0, $a0, $v0
jal   writeln
li    $a0, 24
lw    $v0, 4($gp)
mul   $a0, $a0, $v0
jal   writeln
li    $a0, 24
lw    $v0, 4($gp)
mul   $a0, $a0, $v0
jal   writeln
lw    $v0, 4($gp)
sll   $a0, $v0, 3
jal   writeln
lw    $a0, 0($gp)
lw    $v0, 4($gp)
addu  $v0, $a0, $v0
subu  $a0, $zero, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
_main30:
slti  $v0, $v0, 6
blez  $v0, _main26
li    $a0, 1
jal   writeln
j     _main26
# end _main
