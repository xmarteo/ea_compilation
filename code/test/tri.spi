.data
globals:
.space 16
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main91
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin insertion
insertion114:
li    $a2, 3
insertion99:
addiu $a0, $a2, -1
li    $v0, 2
div   $v0, $a0, $v0
lw    $a0, 4($gp)
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $v0, $a0
bgtz  $a0, insertion90
jr    $ra
insertion90:
lw    $a0, 8($gp)
sll   $a1, $v0, 2
addu  $a1, $a0, $a1
lw    $a1, 0($a1)
sll   $a1, $a1, 1
addiu $a3, $a1, 1
sll   $v0, $v0, 1
addiu $a1, $v0, 1
addiu $t0, $a1, -1
li    $v0, 2
div   $v0, $t0, $v0
bgtz  $v0, insertion68
li    $v0, 1
insertion58:
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, insertion54
lw    $v0, 8($gp)
addiu $a1, $a1, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 2
addu  $v0, $v0, $a0
addiu $a1, $a3, -1
li    $a0, 2
div   $a0, $a1, $a0
sw    $a0, 0($v0)
addiu $a0, $a2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a2, $v0, 3
j     insertion99
insertion54:
lw    $a0, 8($gp)
addiu $a1, $a1, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $a1, $v0, 2
addu  $a1, $a0, $a1
lw    $t0, -4($a1)
sw    $t0, 0($a1)
sll   $v0, $v0, 1
addiu $a1, $v0, -1
addiu $t0, $a1, -1
li    $v0, 2
div   $v0, $t0, $v0
bgtz  $v0, insertion27
li    $v0, 1
j     insertion58
insertion27:
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $t0, -4($v0)
addiu $a0, $a3, -1
li    $v0, 2
div   $v0, $a0, $v0
sgt   $v0, $t0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     insertion58
insertion68:
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $t0, -4($v0)
addiu $a0, $a3, -1
li    $v0, 2
div   $v0, $a0, $v0
sgt   $v0, $t0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     insertion58
# end insertion

# begin _main
_main91:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 400
jal   alloc
sw    $v0, 8($gp)
li    $v0, 1
sw    $v0, 0($gp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 12($gp)
_main72:
lw    $v0, 12($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
bne   $v0, $zero, _main66
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 4($gp)
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   writeln
jal   insertion114
li    $v0, 1
sw    $v0, 0($gp)
_main27:
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
lw    $a0, 4($gp)
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a0, $v0, $a0
bgtz  $a0, _main17
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main17:
lw    $a0, 8($gp)
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $a0, 0($v0)
jal   writeln
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 3
sw    $v0, 0($gp)
j     _main27
_main66:
lw    $a1, 8($gp)
lw    $a0, 0($gp)
addiu $a2, $a0, -1
li    $a0, 2
div   $a0, $a2, $a0
sll   $a2, $a0, 2
addu  $a1, $a1, $a2
sw    $v0, 0($a1)
sll   $v0, $a0, 1
addiu $v0, $v0, 3
sw    $v0, 0($gp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 12($gp)
j     _main72
# end _main
