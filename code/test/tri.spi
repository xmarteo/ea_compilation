.data
globals:
.space 16
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main53
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin insertion
insertion54:
li    $a3, 1
insertion39:
lw    $v0, 4($gp)
slt   $v0, $a3, $v0
bgtz  $v0, insertion36
jr    $ra
insertion36:
lw    $v0, 8($gp)
sll   $a0, $a3, 2
addu  $a0, $v0, $a0
lw    $a1, 0($a0)
move  $a2, $a3
bgtz  $a2, insertion29
li    $v0, 0
insertion24:
bgtz  $v0, insertion23
lw    $v0, 8($gp)
sll   $a0, $a2, 2
addu  $v0, $v0, $a0
sw    $a1, 0($v0)
addiu $a3, $a3, 1
j     insertion39
insertion23:
lw    $v0, 8($gp)
sll   $a0, $a2, 2
addu  $a0, $v0, $a0
lw    $t0, -4($a0)
sw    $t0, 0($a0)
addiu $a2, $a2, -1
bgtz  $a2, insertion12
li    $v0, 0
j     insertion24
insertion12:
sll   $a0, $a2, 2
addu  $v0, $v0, $a0
lw    $v0, -4($v0)
sgt   $v0, $v0, $a1
j     insertion24
insertion29:
sll   $a0, $a2, 2
addu  $v0, $v0, $a0
lw    $v0, -4($v0)
sgt   $v0, $v0, $a1
j     insertion24
# end insertion

# begin _main
_main53:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 400
jal   alloc
sw    $v0, 8($gp)
sw    $zero, 0($gp)
jal   readln
sw    $v0, 12($gp)
_main36:
lw    $v0, 12($gp)
bne   $v0, $zero, _main33
lw    $v0, 0($gp)
sw    $v0, 4($gp)
lw    $a0, 4($gp)
jal   writeln
jal   insertion54
sw    $zero, 0($gp)
_main14:
lw    $v0, 0($gp)
lw    $a0, 4($gp)
slt   $a0, $v0, $a0
bgtz  $a0, _main10
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main10:
lw    $a0, 8($gp)
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $a0, 0($v0)
jal   writeln
lw    $v0, 0($gp)
addiu $v0, $v0, 1
sw    $v0, 0($gp)
j     _main14
_main33:
lw    $a2, 8($gp)
lw    $a0, 0($gp)
sll   $a1, $a0, 2
addu  $a1, $a2, $a1
sw    $v0, 0($a1)
addiu $v0, $a0, 1
sw    $v0, 0($gp)
jal   readln
sw    $v0, 12($gp)
j     _main36
# end _main
