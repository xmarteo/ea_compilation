.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main36
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin somme2
somme2_105:
addiu $sp, $sp, -20
sw    $ra, 0($sp)
lw    $t2, 16($sp)
lw    $t1, 12($sp)
lw    $t0, 8($sp)
lw    $t3, 4($sp)
addiu $t4, $a0, -1
li    $v0, 2
div   $v0, $t4, $v0
beq   $v0, $zero, somme2_81
somme2_46:
addiu $a1, $a1, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
addiu $a2, $a2, -1
li    $a1, 2
div   $a1, $a2, $a1
sll   $a1, $a1, 1
addiu $a1, $a1, 1
addiu $a3, $a3, -1
li    $a2, 2
div   $a2, $a3, $a2
sll   $a2, $a2, 1
addiu $a2, $a2, 1
addiu $t2, $t2, -1
li    $a3, 2
div   $a3, $t2, $a3
sll   $a3, $a3, 1
addiu $a3, $a3, 1
addiu $t2, $t1, -1
li    $t1, 2
div   $t1, $t2, $t1
sll   $t1, $t1, 1
addiu $t2, $t1, 1
addiu $t1, $t0, -1
li    $t0, 2
div   $t0, $t1, $t0
sll   $t0, $t0, 1
addiu $t1, $t0, 1
li    $t0, 1
addiu $t4, $a0, -1
li    $a0, 2
div   $a0, $t4, $a0
addiu $t4, $t3, -1
li    $t3, 2
div   $t3, $t4, $t3
addu  $a0, $a0, $t3
sll   $a0, $a0, 1
addiu $t3, $a0, 1
move  $a0, $v0
sw    $t2, -4($sp)
sw    $t1, -8($sp)
sw    $t0, -12($sp)
sw    $t3, -16($sp)
jal   somme2_105
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
somme2_116:
lw    $ra, 0($sp)
addiu $sp, $sp, 20
jr    $ra
somme2_81:
addiu $t4, $a1, -1
li    $v0, 2
div   $v0, $t4, $v0
bne   $v0, $zero, somme2_46
addiu $t4, $a2, -1
li    $v0, 2
div   $v0, $t4, $v0
bne   $v0, $zero, somme2_46
addiu $t4, $a3, -1
li    $v0, 2
div   $v0, $t4, $v0
bne   $v0, $zero, somme2_46
addiu $t4, $t2, -1
li    $v0, 2
div   $v0, $t4, $v0
bne   $v0, $zero, somme2_46
addiu $t4, $t1, -1
li    $v0, 2
div   $v0, $t4, $v0
bne   $v0, $zero, somme2_46
addiu $t4, $t0, -1
li    $v0, 2
div   $v0, $t4, $v0
bne   $v0, $zero, somme2_46
addiu $a0, $t3, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     somme2_116
# end somme2

# begin somme
somme105:
addiu $sp, $sp, -20
sw    $ra, 0($sp)
lw    $t4, 16($sp)
lw    $t3, 12($sp)
lw    $t6, 8($sp)
lw    $t7, 4($sp)
addiu $t0, $a0, -1
li    $v0, 2
div   $v0, $t0, $v0
beq   $v0, $zero, somme81
somme46:
li    $v0, 1
addiu $t0, $a0, -1
li    $a0, 2
div   $a0, $t0, $a0
sll   $a0, $a0, 1
addiu $t0, $a0, 1
addiu $a1, $a1, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $t1, $a0, 1
addiu $a1, $a2, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $t2, $a0, 1
addiu $a1, $a3, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $t5, $a0, 1
addiu $a1, $t4, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $t4, $a0, 1
addiu $a1, $t3, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addiu $t3, $a0, 1
addiu $a1, $t6, -1
li    $a0, 2
div   $a0, $a1, $a0
addiu $a2, $t7, -1
li    $a1, 2
div   $a1, $a2, $a1
addu  $a0, $a0, $a1
sll   $a0, $a0, 1
addiu $t6, $a0, 1
move  $a0, $v0
move  $a1, $t0
move  $a2, $t1
move  $a3, $t2
sw    $t5, -4($sp)
sw    $t4, -8($sp)
sw    $t3, -12($sp)
sw    $t6, -16($sp)
jal   somme105
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
somme116:
lw    $ra, 0($sp)
addiu $sp, $sp, 20
jr    $ra
somme81:
addiu $t0, $a1, -1
li    $v0, 2
div   $v0, $t0, $v0
bne   $v0, $zero, somme46
addiu $t0, $a2, -1
li    $v0, 2
div   $v0, $t0, $v0
bne   $v0, $zero, somme46
addiu $t0, $a3, -1
li    $v0, 2
div   $v0, $t0, $v0
bne   $v0, $zero, somme46
addiu $t0, $t4, -1
li    $v0, 2
div   $v0, $t0, $v0
bne   $v0, $zero, somme46
addiu $t0, $t3, -1
li    $v0, 2
div   $v0, $t0, $v0
bne   $v0, $zero, somme46
addiu $t0, $t6, -1
li    $v0, 2
div   $v0, $t0, $v0
bne   $v0, $zero, somme46
addiu $a0, $t7, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     somme116
# end somme

# begin _main
_main36:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 3
li    $a1, 5
li    $a2, 7
li    $a3, 9
li    $t2, 11
li    $t1, 13
li    $t0, 15
li    $v0, 1
sw    $t2, -4($sp)
sw    $t1, -8($sp)
sw    $t0, -12($sp)
sw    $v0, -16($sp)
jal   somme105
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   writeln
li    $a0, 3
li    $a1, 5
li    $a2, 7
li    $a3, 9
li    $t2, 11
li    $t1, 13
li    $t0, 15
li    $v0, 1
sw    $t2, -4($sp)
sw    $t1, -8($sp)
sw    $t0, -12($sp)
sw    $v0, -16($sp)
jal   somme2_105
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
