.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main43
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin prod
prod79:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s2, $a0
move  $s3, $a1
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
bltz  $v0, prod56
sll   $v0, $v0, 1
addiu $s0, $v0, 1
prod48:
li    $s1, 1
prod47:
addiu $a0, $s0, -1
li    $v0, 2
div   $a0, $a0, $v0
bgtz  $a0, prod93
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
bltz  $v0, prod11
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
prod90:
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
prod11:
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
subu  $v0, $zero, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     prod90
prod93:
jal   odd24
bgtz  $v0, prod38
prod29:
addiu $a0, $s0, -1
li    $v0, 2
div   $a0, $a0, $v0
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 1
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 2
addiu $s3, $v0, 1
j     prod47
prod38:
addiu $a0, $s1, -1
li    $v0, 2
div   $a1, $a0, $v0
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
addu  $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $s1, $v0, 1
j     prod29
prod56:
subu  $v0, $zero, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 1
j     prod48
# end prod

# begin odd
odd24:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
li    $a0, 2
div   $a0, $v0, $a0
sll   $a0, $a0, 1
sne   $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
jr    $ra
# end odd

# begin _main
_main43:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 4($gp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
_main25:
lw    $v0, 4($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
bne   $a0, $zero, _main15
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main15:
lw    $v0, 0($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $a1, $a1, $v0
jal   prod79
move  $a0, $v0
jal   writeln
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 4($gp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
j     _main25
# end _main
