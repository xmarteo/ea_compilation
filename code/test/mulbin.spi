.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main26
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin prod
prod32:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s2, $a0
move  $s3, $a1
bltz  $s2, prod15
move  $s0, $s2
prod13:
li    $s1, 0
prod12:
bgtz  $s0, prod47
bltz  $s2, prod2
prod44:
move  $v0, $s1
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
prod2:
subu  $s1, $zero, $s1
j     prod44
prod47:
move  $a0, $s0
jal   odd16
bgtz  $v0, prod9
prod8:
li    $v0, 2
div   $s0, $s0, $v0
sll   $s3, $s3, 1
j     prod12
prod9:
addu  $s1, $s1, $s3
j     prod8
prod15:
subu  $s0, $zero, $s2
j     prod13
# end prod

# begin odd
odd16:
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
sne   $v0, $a0, $v0
jr    $ra
# end odd

# begin _main
_main26:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 4($gp)
jal   readln
sw    $v0, 0($gp)
_main12:
lw    $a0, 4($gp)
bne   $a0, $zero, _main8
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main8:
lw    $a1, 0($gp)
jal   prod32
move  $a0, $v0
jal   writeln
jal   readln
sw    $v0, 4($gp)
jal   readln
sw    $v0, 0($gp)
j     _main12
# end _main
