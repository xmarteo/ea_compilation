.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main24
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin min
min31:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $a1, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $a1, $v0, $a0
bgtz  $a1, min7
sll   $v0, $a0, 1
addiu $v0, $v0, 1
min33:
jr    $ra
min7:
sll   $v0, $v0, 1
addiu $v0, $v0, 1
j     min33
# end min

# begin f
f25:
li    $v0, 3
addiu $a2, $a1, -1
li    $a1, 2
div   $a1, $a2, $a1
mul   $v0, $v0, $a1
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
sll   $a0, $a0, 1
addu  $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $v0, $v0, 3
jr    $ra
# end f

# begin efface
efface35:
li    $v0, 1
efface21:
addiu $a2, $v0, -1
li    $v0, 2
div   $v0, $a2, $v0
addiu $a3, $a1, -1
li    $a2, 2
div   $a2, $a3, $a2
slt   $a2, $v0, $a2
bgtz  $a2, efface10
jr    $ra
efface10:
sll   $a2, $v0, 2
addu  $a2, $a0, $a2
sw    $zero, 0($a2)
sll   $v0, $v0, 1
addiu $v0, $v0, 3
j     efface21
# end efface

# begin chiffre
chiffre23:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
bgez  $v0, chiffre4
chiffre1:
li    $v0, 1
chiffre25:
jr    $ra
chiffre4:
slti  $v0, $v0, 10
blez  $v0, chiffre1
li    $v0, 3
j     chiffre25
# end chiffre

# begin branche
branche34:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $a1, -1
li    $a0, 2
div   $a0, $a1, $a0
slt   $v0, $v0, $a0
bgtz  $v0, branche12
li    $v0, 1
branche10:
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 3
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
jr    $ra
branche12:
li    $v0, 3
j     branche10
# end branche

# begin _main
_main24:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 7
li    $a1, 9
jal   f25
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
li    $a1, 11
jal   min31
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
