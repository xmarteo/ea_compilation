.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main16
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin min
min17:
move  $v0, $a1
slt   $a1, $a0, $v0
bgtz  $a1, min2
min19:
jr    $ra
min2:
move  $v0, $a0
j     min19
# end min

# begin f
f18:
li    $v0, 3
mul   $v0, $v0, $a1
sll   $a0, $a0, 1
addu  $v0, $v0, $a0
addiu $v0, $v0, 1
jr    $ra
# end f

# begin efface
efface22:
li    $a2, 0
efface8:
slt   $v0, $a2, $a1
bgtz  $v0, efface6
jr    $ra
efface6:
sll   $v0, $a2, 2
addu  $v0, $a0, $v0
sw    $zero, 0($v0)
addiu $a2, $a2, 1
j     efface8
# end efface

# begin chiffre
chiffre17:
bgez  $a0, chiffre4
chiffre1:
li    $v0, 0
chiffre19:
jr    $ra
chiffre4:
slti  $v0, $a0, 10
blez  $v0, chiffre1
li    $v0, 1
j     chiffre19
# end chiffre

# begin branche
branche20:
slt   $v0, $a0, $a1
bgtz  $v0, branche4
li    $v0, 0
branche2:
addiu $v0, $v0, 1
jr    $ra
branche4:
li    $v0, 1
j     branche2
# end branche

# begin _main
_main16:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 3
li    $a1, 4
jal   f18
li    $a1, 5
move  $a0, $v0
jal   min17
move  $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
