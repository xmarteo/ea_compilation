.data
globals:
.space 0
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main17
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin many
many40:
addiu $sp, $sp, -32
sw    $ra, 20($sp)
sw    $a1, 16($sp)
sw    $a2, 12($sp)
sw    $a3, 8($sp)
lw    $v1, 28($sp)
sw    $v1, 4($sp)
lw    $v1, 24($sp)
sw    $v1, 0($sp)
addiu $a0, $a0, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   ecrit15
lw    $v1, 16($sp)
addiu $a0, $v1, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   ecrit15
lw    $v1, 12($sp)
addiu $a0, $v1, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   ecrit15
lw    $v1, 8($sp)
addiu $a0, $v1, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   ecrit15
lw    $v1, 4($sp)
addiu $a0, $v1, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   ecrit15
lw    $v1, 0($sp)
addiu $a0, $v1, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $ra, 20($sp)
addiu $sp, $sp, 32
j     ecrit15
# end many

# begin ecrit
ecrit15:
addiu $a0, $a0, -1
li    $v0, 2
div   $a0, $a0, $v0
j     writeln
# end ecrit

# begin _main
_main17:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
li    $a0, 1
li    $a1, 2
li    $a2, 3
li    $a3, 4
li    $t0, 5
li    $v0, 6
sw    $t0, -4($sp)
sw    $v0, -8($sp)
jal   many40
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
# end _main
