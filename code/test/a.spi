.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main50
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin g
g17:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
jr    $ra
# end g

# begin f
f62:
addiu $sp, $sp, -24
lw    $v0, 20($sp)
lw    $t0, 16($sp)
lw    $t1, 12($sp)
lw    $t2, 8($sp)
lw    $t3, 4($sp)
lw    $t4, 0($sp)
addiu $t5, $a0, -1
li    $a0, 2
div   $a0, $t5, $a0
addiu $t5, $a1, -1
li    $a1, 2
div   $a1, $t5, $a1
addu  $a0, $a0, $a1
addiu $a2, $a2, -1
li    $a1, 2
div   $a1, $a2, $a1
addu  $a0, $a0, $a1
addiu $a2, $a3, -1
li    $a1, 2
div   $a1, $a2, $a1
addu  $a0, $a0, $a1
addiu $a1, $v0, -1
li    $v0, 2
div   $v0, $a1, $v0
addu  $v0, $a0, $v0
addiu $a1, $t0, -1
li    $a0, 2
div   $a0, $a1, $a0
addu  $v0, $v0, $a0
addiu $a1, $t1, -1
li    $a0, 2
div   $a0, $a1, $a0
addu  $v0, $v0, $a0
addiu $a1, $t2, -1
li    $a0, 2
div   $a0, $a1, $a0
addu  $v0, $v0, $a0
addiu $a1, $t3, -1
li    $a0, 2
div   $a0, $a1, $a0
addu  $v0, $v0, $a0
addiu $a1, $t4, -1
li    $a0, 2
div   $a0, $a1, $a0
addu  $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
addiu $sp, $sp, 24
jr    $ra
# end f

# begin _main
_main50:
addiu $sp, $sp, -32
sw    $ra, 28($sp)
li    $v0, 3
sw    $v0, 0($gp)
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v1, $v0, 1
sw    $v1, 0($sp)
li    $a0, 5
jal   g17
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v1, $v0, 1
sw    $v1, 4($sp)
li    $v1, 7
sw    $v1, 8($sp)
li    $v1, 9
sw    $v1, 12($sp)
li    $v1, 11
sw    $v1, 16($sp)
li    $v1, 13
sw    $v1, 20($sp)
li    $v1, 15
sw    $v1, 24($sp)
li    $a0, 17
jal   g17
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   g17
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $t1, $v0, 1
li    $t0, 19
li    $v0, 21
lw    $a0, 0($sp)
lw    $a1, 4($sp)
lw    $a2, 8($sp)
lw    $a3, 12($sp)
lw    $v1, 16($sp)
sw    $v1, -4($sp)
lw    $v1, 20($sp)
sw    $v1, -8($sp)
lw    $v1, 24($sp)
sw    $v1, -12($sp)
sw    $t1, -16($sp)
sw    $t0, -20($sp)
sw    $v0, -24($sp)
jal   f62
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $ra, 28($sp)
addiu $sp, $sp, 32
j     writeln
# end _main
