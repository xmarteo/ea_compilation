.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main23
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin other
other36:
addiu $a2, $a0, -1
li    $v0, 2
div   $a2, $a2, $v0
li    $v0, 1
beq   $a2, $v0, other18
other12:
addiu $a0, $a0, -1
li    $v0, 2
div   $a0, $a0, $v0
li    $v0, 1
beq   $a0, $v0, other7
other1:
li    $v0, 3
other38:
jr    $ra
other7:
addiu $a0, $a1, -1
li    $v0, 2
div   $a0, $a0, $v0
li    $v0, 3
bne   $a0, $v0, other1
li    $v0, 5
j     other38
other18:
addiu $a2, $a1, -1
li    $v0, 2
div   $a2, $a2, $v0
li    $v0, 2
bne   $a2, $v0, other12
li    $v0, 7
j     other38
# end other

# begin hanoi
hanoi76:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a1
move  $s3, $a2
hanoi62:
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
bgtz  $v0, hanoi58
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
hanoi58:
addiu $a0, $s2, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
addiu $a1, $s3, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
jal   other36
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 1
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, -1
addiu $a1, $s2, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
addiu $a2, $s0, -1
li    $v0, 2
div   $v0, $a2, $v0
sll   $v0, $v0, 1
addiu $a2, $v0, 1
jal   hanoi76
li    $v0, 10
addiu $a1, $s2, -1
li    $a0, 2
div   $a0, $a1, $a0
mul   $a1, $v0, $a0
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
addu  $a0, $a1, $v0
jal   writeln
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s1, $v0, -1
addiu $a0, $s0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s2, $v0, 1
addiu $a0, $s3, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s3, $v0, 1
j     hanoi62
# end hanoi

# begin _main
_main23:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
li    $a1, 3
li    $a2, 7
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     hanoi76
# end _main
