.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main16
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin other
other24:
li    $v0, 1
beq   $a0, $v0, other9
other6:
li    $v0, 1
beq   $a0, $v0, other4
other1:
li    $v0, 1
other26:
jr    $ra
other4:
li    $v0, 3
bne   $a1, $v0, other1
li    $v0, 2
j     other26
other9:
li    $v0, 2
bne   $a1, $v0, other6
li    $v0, 3
j     other26
# end other

# begin hanoi
hanoi24:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a1
move  $s3, $a2
hanoi10:
bgtz  $s1, hanoi51
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
hanoi51:
move  $a0, $s2
move  $a1, $s3
jal   other24
move  $s0, $v0
addiu $a0, $s1, -1
move  $a1, $s2
move  $a2, $s0
jal   hanoi24
li    $v0, 10
mul   $v0, $v0, $s2
addu  $a0, $v0, $s3
jal   writeln
addiu $s1, $s1, -1
move  $s2, $s0
j     hanoi10
# end hanoi

# begin _main
_main16:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 0($gp)
lw    $a0, 0($gp)
li    $a1, 1
li    $a2, 3
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     hanoi24
# end _main
