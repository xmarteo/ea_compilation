.data
globals:
.space 12
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main27
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin input
input27:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s3, $a0
sll   $v0, $s3, 2
addiu $a0, $v0, 4
jal   alloc
move  $s1, $v0
li    $s2, 1
input9:
sle   $v0, $s2, $s3
bgtz  $v0, input7
move  $v0, $s1
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
input7:
sll   $v0, $s2, 2
addu  $s0, $s1, $v0
jal   readln
sw    $v0, 0($s0)
addiu $s2, $s2, 1
j     input9
# end input

# begin find
find68:
li    $t3, 1
find49:
slt   $v0, $t3, $a0
bgtz  $v0, find47
jr    $ra
find47:
sll   $v0, $a1, 2
addu  $v0, $a2, $v0
lw    $t2, 0($v0)
move  $t5, $t3
move  $t4, $a0
find42:
sle   $v0, $t5, $t4
bgtz  $v0, find40
sle   $v0, $a1, $t4
bgtz  $v0, find7
sle   $v0, $t5, $a1
bgtz  $v0, find4
move  $a0, $a1
move  $t3, $a0
j     find49
find4:
move  $t3, $t5
j     find49
find7:
move  $a0, $t4
j     find49
find40:
sll   $v0, $t5, 2
addu  $v0, $a2, $v0
lw    $v0, 0($v0)
slt   $v0, $v0, $t2
bgtz  $v0, find35
find33:
sll   $v0, $t4, 2
addu  $v0, $a2, $v0
lw    $a3, 0($v0)
slt   $t0, $t2, $a3
bgtz  $t0, find28
sle   $t0, $t5, $t4
blez  $t0, find42
sll   $t0, $t5, 2
addu  $t0, $a2, $t0
lw    $t1, 0($t0)
sw    $a3, 0($t0)
sw    $t1, 0($v0)
addiu $t5, $t5, 1
addiu $t4, $t4, -1
j     find42
find28:
addiu $t4, $t4, -1
j     find33
find35:
addiu $t5, $t5, 1
j     find40
# end find

# begin _main
_main27:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 4($gp)
jal   readln
sw    $v0, 8($gp)
lw    $a0, 8($gp)
jal   input27
sw    $v0, 0($gp)
lw    $a0, 8($gp)
lw    $a1, 4($gp)
lw    $a2, 0($gp)
jal   find68
lw    $a0, 0($gp)
lw    $v0, 4($gp)
sll   $v0, $v0, 2
addu  $v0, $a0, $v0
lw    $a0, 0($v0)
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
