.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main18
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin power
power28:
li    $v0, 1
power11:
bgtz  $a1, power10
jr    $ra
power10:
li    $a2, 2
div   $a2, $a1, $a2
sll   $a2, $a2, 1
bne   $a1, $a2, power6
power5:
li    $a2, 2
div   $a1, $a1, $a2
mul   $a0, $a0, $a0
j     power11
power6:
mul   $v0, $v0, $a0
j     power5
# end power

# begin _main
_main18:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 4($gp)
jal   readln
sw    $v0, 0($gp)
lw    $a0, 4($gp)
lw    $a1, 0($gp)
jal   power28
move  $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
