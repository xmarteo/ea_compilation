.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main25
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin sum
sum22:
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
addiu $a1, $a1, -1
li    $a0, 2
div   $a0, $a1, $a0
addu  $v0, $v0, $a0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
jr    $ra
# end sum

# begin fib2
fib2_51:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
li    $a1, -3
jal   sum22
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s1, $v0, 1
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
slti  $a0, $v0, 2
bgtz  $a0, fib2_22
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib1_44
addiu $a0, $v0, -1
li    $v0, 2
div   $s0, $a0, $v0
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib2_51
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
addu  $v0, $s0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
fib2_62:
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
fib2_22:
li    $v0, 3
j     fib2_62
# end fib2

# begin fib1
fib1_44:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s1, $v0, -1
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
slti  $a0, $v0, 2
bgtz  $a0, fib1_22
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib1_44
addiu $a0, $v0, -1
li    $v0, 2
div   $s0, $a0, $v0
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib2_51
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
addu  $v0, $s0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
fib1_55:
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
fib1_22:
li    $v0, 3
j     fib1_55
# end fib1

# begin fib
fib46:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
slti  $a0, $v0, 2
bgtz  $a0, fib29
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib1_44
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $s0, $v0, 1
addiu $a0, $s1, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib2_51
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a1, $v0, 1
move  $a0, $s0
jal   sum22
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
fib57:
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
fib29:
li    $v0, 3
j     fib57
# end fib

# begin _main
_main25:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sll   $v0, $v0, 1
addiu $v0, $v0, 1
sw    $v0, 0($gp)
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
jal   fib46
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
