.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main15
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin sum
sum14:
addu  $v0, $a0, $a1
jr    $ra
# end sum

# begin fib2
fib2_20:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
li    $a1, -2
move  $a0, $s1
jal   sum14
move  $s1, $v0
slti  $v0, $s1, 2
bgtz  $v0, fib2_4
move  $a0, $s1
jal   fib1_19
move  $s0, $v0
move  $a0, $s1
jal   fib2_20
addu  $v0, $s0, $v0
fib2_31:
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
fib2_4:
li    $v0, 1
j     fib2_31
# end fib2

# begin fib1
fib1_19:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
addiu $s1, $s1, -1
slti  $v0, $s1, 2
bgtz  $v0, fib1_4
move  $a0, $s1
jal   fib1_19
move  $s0, $v0
move  $a0, $s1
jal   fib2_20
addu  $v0, $s0, $v0
fib1_30:
lw    $ra, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 12
jr    $ra
fib1_4:
li    $v0, 1
j     fib1_30
# end fib1

# begin fib
fib18:
addiu $sp, $sp, -12
sw    $ra, 8($sp)
sw    $s0, 4($sp)
move  $s0, $a0
slti  $v0, $s0, 2
bgtz  $v0, fib4
move  $a0, $s0
jal   fib1_19
sw    $v0, 0($sp)
move  $a0, $s0
jal   fib2_20
lw    $a0, 0($sp)
move  $a1, $v0
lw    $ra, 8($sp)
lw    $s0, 4($sp)
addiu $sp, $sp, 12
j     sum14
fib4:
li    $v0, 1
lw    $ra, 8($sp)
lw    $s0, 4($sp)
addiu $sp, $sp, 12
jr    $ra
# end fib

# begin _main
_main15:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 0($gp)
lw    $a0, 0($gp)
jal   fib18
move  $a0, $v0
lw    $ra, 0($sp)
addiu $sp, $sp, 4
j     writeln
# end _main
