.data
globals:
.space 8
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main27
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin output
output22:
addiu $sp, $sp, -16
sw    $ra, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s1, $a0
move  $s2, $a1
li    $s0, 0
output8:
slt   $v0, $s0, $s2
bgtz  $v0, output6
lw    $ra, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 16
jr    $ra
output6:
sll   $v0, $s0, 2
addu  $v0, $s1, $v0
lw    $a0, 0($v0)
jal   writeln
addiu $s0, $s0, 1
j     output8
# end output

# begin input
input26:
addiu $sp, $sp, -20
sw    $ra, 16($sp)
sw    $s3, 12($sp)
sw    $s2, 8($sp)
sw    $s1, 4($sp)
sw    $s0, 0($sp)
move  $s3, $a0
sll   $a0, $s3, 2
jal   alloc
move  $s1, $v0
li    $s2, 0
input9:
slt   $v0, $s2, $s3
bgtz  $v0, input7
move  $v0, $s1
lw    $ra, 16($sp)
lw    $s3, 12($sp)
lw    $s2, 8($sp)
lw    $s1, 4($sp)
lw    $s0, 0($sp)
addiu $sp, $sp, 20
jr    $ra
input7:
sll   $v0, $s2, 2
addu  $s0, $s1, $v0
jal   readln
sw    $v0, 0($s0)
addiu $s2, $s2, 1
j     input9
# end input

# begin dutch
dutch66:
li    $a3, 0
li    $t0, 0
lw    $a2, 0($gp)
dutch51:
slt   $v0, $a3, $a2
bgtz  $v0, dutch49
jr    $ra
dutch49:
lw    $v0, 4($gp)
sll   $a0, $a3, 2
addu  $a0, $v0, $a0
lw    $a1, 0($a0)
beq   $a1, $zero, dutch42
li    $t1, 1
beq   $a1, $t1, dutch19
addiu $a2, $a2, -1
sll   $t1, $a2, 2
addu  $v0, $v0, $t1
lw    $t1, 0($v0)
sw    $a1, 0($v0)
sw    $t1, 0($a0)
j     dutch51
dutch19:
addiu $a3, $a3, 1
j     dutch51
dutch42:
sll   $t1, $t0, 2
addu  $v0, $v0, $t1
lw    $t1, 0($v0)
sw    $a1, 0($v0)
sw    $t1, 0($a0)
addiu $t0, $t0, 1
addiu $a3, $a3, 1
j     dutch51
# end dutch

# begin _main
_main27:
addiu $sp, $sp, -4
sw    $ra, 0($sp)
jal   readln
sw    $v0, 0($gp)
_main15:
lw    $a0, 0($gp)
bgtz  $a0, _main49
lw    $ra, 0($sp)
addiu $sp, $sp, 4
jr    $ra
_main49:
jal   input26
sw    $v0, 4($gp)
lw    $a0, 4($gp)
lw    $a1, 0($gp)
jal   output22
jal   dutch66
lw    $a0, 4($gp)
lw    $a1, 0($gp)
jal   output22
jal   readln
sw    $v0, 0($gp)
j     _main15
# end _main
