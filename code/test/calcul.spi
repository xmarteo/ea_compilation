.data
globals:
.space 4
heap_info:
	.space 12
    .text
main:
la    $gp, globals
# allocate the heap
li    $a0, 65536
li    $v0, 9
syscall
# saving heap size
move  $a2, $a0
# computing heap_info
la    $a0, heap_info
# beginning of heap
sw    $v0, 0($a0)
# current position
sw    $v0, 4($a0)
# end of heap
add   $a2, $a2, $v0
sw    $a2, 8($a0)
j     _main28
write:
li    $v0, 1
syscall
j     $ra
.data
nl:
.asciiz "\n"
.align 2
.text
writeln:
li    $v0, 1
syscall
la    $a0, nl
li    $v0, 4
syscall
j     $ra
readln:
li    $v0, 5
syscall
j     $ra
alloc:
la    $a1, heap_info
# adding extra word
addi  $t1, $a0, 4
# current position
lw    $v0, 4($a1)
move  $t0, $v0
# end of the heap
lw    $a2, 8($a1)
add   $v0, $t1, $v0
# must have v0<=a2
bgt   $v0, $a2, oom
sw    $v0, 4($a1)
# length is written
move  $v0, $t0
div   $a0, $a0, 4
sw    $a0, 0($v0)
addi  $v0, $v0, 4
j     $ra
.data
error_str:
.asciiz "out0fMem"
.align 2
.text
oom:
# means out of mem.
la $a0, error_str
li $v0, 4
syscall
li $v0, 10
syscall
j     $ra

# begin f
f47:
addiu $a0, $a0, -1
li    $v0, 2
div   $a0, $a0, $v0
lw    $v0, 0($gp)
addiu $a1, $v0, -1
li    $v0, 2
div   $v0, $a1, $v0
sll   $v0, $v0, 1
addu  $a0, $a0, $v0
sll   $a0, $a0, 1
addiu $a0, $a0, 1
addiu $v0, $v0, 3
sw    $v0, 0($gp)
li    $v0, 5
addiu $a1, $a0, -1
li    $a0, 2
div   $a0, $a1, $a0
mul   $a1, $v0, $a0
lw    $v0, 0($gp)
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
addu  $v0, $a1, $v0
sll   $v0, $v0, 1
addiu $a0, $v0, 1
addiu $a0, $a0, -1
li    $v0, 2
div   $v0, $a0, $v0
sll   $v0, $v0, 1
addiu $v0, $v0, 1
jr    $ra
# end f

# begin _main
_main28:
addiu $sp, $sp, -8
sw    $ra, 4($sp)
li    $a0, 1
jal   f47
addiu $a0, $v0, -1
li    $v0, 2
div   $a0, $a0, $v0
jal   writeln
li    $a0, 3
jal   f47
addiu $a0, $v0, -1
li    $v0, 2
div   $v1, $a0, $v0
sw    $v1, 0($sp)
li    $a0, 5
jal   f47
addiu $a0, $v0, -1
li    $v0, 2
div   $v0, $a0, $v0
lw    $v1, 0($sp)
addu  $a0, $v1, $v0
lw    $ra, 4($sp)
addiu $sp, $sp, 8
j     writeln
# end _main
